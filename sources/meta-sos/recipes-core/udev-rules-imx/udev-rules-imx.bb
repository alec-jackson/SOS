# This is a fake recipe used to satisfy the incorrect recipe in meta-imx-bsp
LICENSE = "CLOSED"